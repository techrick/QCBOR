## zephyr/Kconfig
```kconfig
# Minimalistic CBOR decoder implementation

config QCBOR
	bool "QCBOR Support"
	help
	  This option enables the QCBOR library.
```
